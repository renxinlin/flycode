# Keil uVision project fly_sky_software.uvprojx, settings and files
target fly_sky_software (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: fly_sky_software +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F103_DMP,MPU6050,EMPL,MPL_LOG_NDEBUG=1
  c include: ../Core/Inc;C:/Users/mac/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/mac/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/mac/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/mac/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/CMSIS/Include;.\fly_sky_software;.\fly_sky_software\system;.\fly_sky_software\common;.\fly_sky_software\drivers\soft;.\fly_sky_software\control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c adc.c
    ./fly_sky_software/system/: delay.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/mac/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.4/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/Soft
    ../Core/Src/: spi.c
    ./fly_sky_software/: iic.c mpu.c
    ./fly_sky_software/drivers/soft/: fbm320.c nrf2401.c bmp280.c
  group Drivers/Soft/dmp
    ./fly_sky_software/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group common
    ./fly_sky_software/common/: filter.c maths.c
  group control
    ./fly_sky_software/control/: innerControl.c outterControl.c pid.c imu.c positionEstimate.c control.c data.c protocol.c sensors.c
  group system
    ./fly_sky_software/system/: tim.c
software components: CMSIS:CORE 4.3.0
